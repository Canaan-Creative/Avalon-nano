# Keil uVision project lib_lpc_board_nxp_lpcxpresso_11u14.uvproj, settings and files
target nxp_lpcxpresso_11u14 (ARM-ADS)
  device: LPC11U14/201 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10000FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: board_nxp_lpcxpresso_11u14 (library)
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M0
  c include: .\inc;..\lpc_chip_11uxx_lib\inc
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x1000
  group board_nxp_lpcxpresso_11u14
    ./src/: board.c board_sysinit.c
