# Keil uVision project code.uvproj, settings and files
target testbench (ARM-ADS)
  device: LPC11U14FET48/201 NXP
  cpu: IROM(0x00000000,0x8000) IRAM(0x10000000,0x1000) IRAM2(0x20004000,0x0800) CPUTYPE("Cortex-M0+") CLOCK(50000000) ELITTLE
  output: testbench +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M0
  c include: ..\nxplib\lpc_chip_11uxx_lib\inc;..\nxplib\nxp_lpcxpresso_11u14_board_lib\inc;..\nxplib\lpc_chip_11uxx_lib\inc\usbd;.\inc
  asm define: NO_CRP
  asm misc: --cpreproc
  asm include: ..\nxplib\lpc_chip_11uxx_lib\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x1000
  memory RVCT10: RAM 0x20004000 size 0x800
  group src
    ./src/: avalon_a3233.c avalon_adc.c avalon_iic.c avalon_led.c avalon_pwm.c avalon_timer.c avalon_usb.c avalon_wdt.c cdc_desc.c cdc_uart.c main.c printf.c sha2.c sysinit.c keil_startup_lpc11xx.s
  group lib
    ../nxplib/lpc_chip_11uxx_lib/libs/keil/: usbd_11uxx_lib.lib
    ../nxplib/lpc_chip_11uxx_lib/keil_output/chip_11uxx_lib/: chip_11uxx_lib.lib
    ../nxplib/nxp_lpcxpresso_11u14_board_lib/keil_output/: board_nxp_lpcxpresso_11u14.lib
